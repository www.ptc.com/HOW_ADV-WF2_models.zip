# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C040) (file connecting_rod_2.prt)

Parameters:
  PTC_COMMON_NAME = "connecting_rod.prt"