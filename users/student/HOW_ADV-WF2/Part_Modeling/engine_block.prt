# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C020) (file engine_block.prt)

Parameters:
  PTC_COMMON_NAME = "engine_block.prt"