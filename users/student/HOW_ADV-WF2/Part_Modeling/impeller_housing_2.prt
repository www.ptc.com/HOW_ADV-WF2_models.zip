# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C040) (file impeller_housing_2.prt)

Parameters:
  PTC_COMMON_NAME = "impeller_housing.prt"