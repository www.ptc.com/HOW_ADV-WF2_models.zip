# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C020) (file carburetor.prt)

Parameters:
  PTC_COMMON_NAME = "carburetor.prt"