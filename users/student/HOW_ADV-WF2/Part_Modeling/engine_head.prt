# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C020) (file engine_head.prt)

Parameters:
  PTC_COMMON_NAME = "engine_head.prt"