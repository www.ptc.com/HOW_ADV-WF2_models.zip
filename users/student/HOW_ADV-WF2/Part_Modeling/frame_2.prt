# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C040) (file frame_2.prt)

Parameters:
  PTC_COMMON_NAME = "frame.prt"