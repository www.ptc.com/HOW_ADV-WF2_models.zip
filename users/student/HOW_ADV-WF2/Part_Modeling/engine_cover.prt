# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C020) (file engine_cover.prt)

Parameters:
  PTC_COMMON_NAME = "engine_cover.prt"