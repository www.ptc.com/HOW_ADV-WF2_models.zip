# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C040) (file engine_head_2.prt)

Parameters:
  PTC_COMMON_NAME = "engine_head.prt"