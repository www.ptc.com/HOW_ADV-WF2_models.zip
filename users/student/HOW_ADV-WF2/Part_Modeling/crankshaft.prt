# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C040) (file crankshaft.prt)

Parameters:
  PTC_COMMON_NAME = "crankshaft.prt"