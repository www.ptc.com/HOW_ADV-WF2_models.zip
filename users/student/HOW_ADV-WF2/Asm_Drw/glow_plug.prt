# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C040) (file glow_plug.prt)

Parameters:
  PTC_COMMON_NAME = "glow_plug.prt"