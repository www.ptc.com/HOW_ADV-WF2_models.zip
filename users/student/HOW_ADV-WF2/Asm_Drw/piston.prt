# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C040) (file piston.prt)

Parameters:
  PTC_COMMON_NAME = "piston.prt"