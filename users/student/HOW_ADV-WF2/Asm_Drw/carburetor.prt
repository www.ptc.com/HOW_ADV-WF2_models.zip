# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (C040) (file carburetor.prt)

Parameters:
  PTC_COMMON_NAME = "carburetor.prt"